# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: demo.c led.h led.c independent_keys.c independent_keys.h delay.c delay.h nixie_tube.c nixie_tube.h lcd1602.c lcd1602.h matrix_keys.c matrix_keys.h timer.c timer.h serial.c serial.h matrix_led.c matrix_led.h ds1302.c ds1302.h
